# Keil uVision project 课设.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 课设 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Keyscan.c Smg.c Delay.c TLC5628.c
