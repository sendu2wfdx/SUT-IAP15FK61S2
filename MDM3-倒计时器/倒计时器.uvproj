# Keil uVision project 倒计时器.uvproj, settings and files
target 单片机课设 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 倒计时器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 倒计时器
    ./: main.c Display.C CH452W4.C Delay.C
